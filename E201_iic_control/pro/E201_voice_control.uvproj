# Keil uVision project E201_voice_control.uvproj, settings and files
target E201_control (MCS-51)
  device: SC93F8333 SC93Fxx Series
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF)  XRAM(0-0x3FF) CLOCK(24000000)
  output: E201_voice_control +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\bsp;..\lib;..\TimeOut;..\user
  group startup
    ./: STARTUP.A51
  group user
    ../user/: main.c system.c
  group lib
    ../lib/: SC93F833x_C.H
  group bsp
    ../bsp/: bsp_led.c bsp_timer.c bsp_uart.c bsp_i2c.c bsp_i2c_port.c bsp_i2c_s.c
  group TimeOut
    ../TimeOut/: TimeOut.c
